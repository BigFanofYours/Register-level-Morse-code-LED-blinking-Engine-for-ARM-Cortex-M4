# Keil uVision project GPIO.uvprojx, settings and files
target STM32F407VETx (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Delay;.\application\morse;.\arch\cortex_m4\gpio;.\arch\cortex_m4\irq;.\arch\cortex_m4\nvic;.\arch\cortex_m4\rcc;.\arch\cortex_m4\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Root
    ./: main.c system_stm32f4xx.c startup_stm32f407xx.s
  group Delay
    Delay/: nt_ppd_delay.c nt_ppd_delay.h
  group application\morse
    application/morse/: nt_ppd_morse.c nt_ppd_morse.h
  group arch\cortex_m4\gpio
    arch/cortex_m4/gpio/: nt_ppd_gpio.c nt_ppd_gpio.h nt_ppd_gpio_registers.h
  group arch\cortex_m4\irq
    arch/cortex_m4/irq/: nt_ppd_irq.c nt_ppd_irq.h
  group arch\cortex_m4\nvic
    arch/cortex_m4/nvic/: nt_ppd_nvic.c nt_ppd_nvic.h nt_ppd_nvic_registers.h
  group arch\cortex_m4\rcc
    arch/cortex_m4/rcc/: nt_ppd_rcc.c nt_ppd_rcc.h nt_ppd_rcc_registers.h
  group arch\cortex_m4\usart
    arch/cortex_m4/usart/: nt_ppd_usart.c nt_ppd_usart.h nt_ppd_usart_registers.h
